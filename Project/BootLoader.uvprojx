# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\Library\inc;..\User;..\System\delay;..\System\sys;..\App\timer;..\App\usart;..\App\esp8266;..\App\iap;..\App\key;..\App\md5;..\App\mqtt;..\App\ota;..\App\tencentyun
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_md.s
  group Library
    ../Library/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group App
    ../App/timer/: timer.c
    ../App/usart/: usart.c
    ../App/esp8266/: esp8266.c
    ../App/iap/: iap.c
    ../App/key/: key.c
    ../App/md5/: md5.c
    ../App/ota/: ota.c
    ../App/tencentyun/: tencent_mqtt.c
  group MQTT
    ../App/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
